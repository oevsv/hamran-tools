options:
  parameters:
    generate_options: qt_gui
    id: grcudp
    output_language: python
    title: GnuRadio UDP Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4_000_000'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '1'
    ipv6: 'True'
    notify_missed: 'True'
    port: '2000'
    src_zeros: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: 53e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: tab@1
    showports: 'True'
    tr_level: '-50'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.1'
    ymax: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab@0
    size: int(100e-6*samp_rate)
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Time
    label1: Frequency
    num_tabs: '2'
  states: {}

connections:
- [network_udp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [network_udp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
